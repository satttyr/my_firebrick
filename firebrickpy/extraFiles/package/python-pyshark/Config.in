## firebrickpy/extraFiles/package/python-pyshark/Config.in
```kconfig
config BR2_PACKAGE_PYTHON_PYSHARK
	bool "python-pyshark"
	depends on BR2_PACKAGE_PYTHON
	help
	  python-pyshark package
```
